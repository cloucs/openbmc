FILESEXTRAPATHS:prepend := "${THISDIR}/linux-aspeed:"
SRC_URI += "file://tiogapass.cfg"
SRC_URI += "file://0001-tiogapass-flash-layout.patch"
